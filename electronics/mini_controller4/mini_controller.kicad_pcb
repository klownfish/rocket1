# Repository klownfish/rocket1

File README.md:

# Rocket1
best flight so far:

https://www.youtube.com/watch?v=-uDBPg2TM70

Maiden flight:

https://www.youtube.com/watch?v=-uDBPg2TM70

## structure
The body tube is a 50mm mailing and everything else is 3d printed. Everything is assembled with m2 screws and glue. PETG is used for the baffle and engine mount while PLA is used for everything else. I also glued a layer of tinfoil to the baffle but that's probably not necessary. The total weight with electronics is about 350g.

## recovery
To ensure a safe recovery the parachute is a 90cm rip-stop from klima. Instead of conventional recovery wadding i designed and 3d-printed a baffle that lets pressure but not particles through. So far it has worked very well but it took a few tries before i realised the walls need to be 3mm thick. 
The parachute is pretty big so it can drift 200m and land in a tree :(

a failed baffle

grainy pic after me shooting it down from a tree with bow and arrow

the whole rocket

engine mount

baffle

## KiCad design electronics/mini_controller4/mini_controller.kicad_pcb

Parts:
AE1: APAE1575R1240ABDD1-T
AE2: ANT_868; ANT-868-PW-LP
BZ1: CMT-0502-75-SMT-TR; XDCR_CMT-0502-75-SMT-TR
C1, C4, C6, C7: 0.1u; C_0402_1005Metric
C2, C3: 1u; C_0402_1005Metric
C5: 4.7u; C_0402_1005Metric
D1, D3: ZLLS350TA; D_SOD-523
D2: LED; D_0402_1005Metric
F1: C1H25; Fuse_1206_3216Metric_Pad1.42x1.75mm_HandSolder
H1, H2: MountingHole_Pad; MountingHole_2.2mm_M2_ISO7380_Pad_TopOnly
J1: Conn_01x06; TerminalBlock_Phoenix_MPT-0,5-6-2.54_1x06_P2.54mm_Horizontal
J2: Conn_01x06; JST_SH_BM06B-SRSS-TB_1x06-1MP_P1.00mm_Vertical
J6: SWDIO; just_a_pad
J7: SWCLK; just_a_pad
Q1: MMBT3904; SOT-23
R1: 400; R_0402_1005Metric
R5, R13, R14, R15, R16: 500; R_0402_1005Metric
R7, R10, R17, R18, R19, R20: 10k; R_0402_1005Metric
R8: 3k; R_0402_1005Metric
R11, R12: 4.7k; R_0402_1005Metric
U1: JST-RCY; xt30_pigtail
U2: BU33SD5WG; SOT-23-5
U3: ADXL343; LGA-14_3x5mm_P0.8mm_LayoutBorder1x6y
U4: MAX-M8C; ublox_MAX
U5, U6: Si7232DN; Vishay_PowerPAK_1212-8_Dual
U7: AT25XE041B-XMHN-T; TSSOP-8_4.4x3mm_P0.65mm
U8: s76s
U9: MS5607-02BA; LGA-8_3x5mm_P1.25mm
U10: SKY65723-81; Skyworks_SKY65404-31

Connections:
/3V3: BZ1.1 (-), C1.2, C3.2, C4.2, C5.1, C6.1, C7.2, J2.3, R11.1, R12.2, U2.5 (VOUT), U3.1 (Vdd_I/O), U3.3 (RES), U3.6 (Vs), U3.7 (~CS), U4.7 (VCC_IO), U4.8 (VCC), U7.3 (~WP~/IO2), U7.7 (~HOLD~/IO3), U7.8 (VCC), U8.43 (VDD), U8.44 (VDD), U9.1 (VDD), U9.2 (PS), U10.1 (VCC)
/BAT_SENSE: R7.2, R8.1, U8.6 (PC2)
/BOOT0: J2.2, R10.1, U8.59 (BOOT0)
/BUZZER: R5.2, U8.36 (PA1_RF_FEM_CPS)
/EXT_MISC: J2.1, U8.54 (PC12)
/EXT_RX: J2.5, U8.46 (PA10_USART1_RX)
/EXT_TX: J2.4, U8.47 (PA9_USART1_TX)
/FLASH_CS: U7.1 (~CS), U8.18 (PA4_SPI1_NSS)
/FLASH_MISO: U7.2 (SO/IO1), U8.20 (PA6_SPI1_MISO)
/FLASH_MOSI: U7.5 (SI/IO0), U8.21 (PA7_SPI1_MOSI)
/FLASH_SCK: U7.6 (SCK), U8.19 (PA5_SPI1_SCK)
/GPS_RX: U4.2 (TXD), U8.53 (PC11)
/GPS_TX: U4.3 (RXD), U8.52 (PC10)
/LED: R1.2, U8.26 (PC6)
/PYRO_1: J1.6, U5.6 (D1)
/PYRO_1_EN: R13.1, R19.1, U8.58 (PB7_SDA)
/PYRO_1_MOS: R13.2, U5.2 (G1)
/PYRO_2: J1.4, U5.5 (D2)
/PYRO_2_EN: R15.1, R20.1, U8.57 (PB6_SCL)
/PYRO_2_MOS: R15.2, U5.4 (G2)
/PYRO_3: J1.3, U6.6 (D1)
/PYRO_3_EN: R14.1, R17.2, U8.56 (PB5)
/PYRO_3_MOS: R14.2, U6.2 (G1)
/PYRO_4: J1.1, U6.5 (D2)
/PYRO_4_EN: R16.2, R18.2, U8.55 (PD2)
/PYRO_4_MOS: R16.1, U6.4 (G2)
/SCL3: R11.2, U3.14 (SCL/SCLK), U8.4 (PC0), U9.8 (SCLK)
/SDA3: R12.1, U3.13 (SDA/SDI/SDIO), U8.5 (PC1), U9.7 (SDI/SDA)
/SWCLK: J7.1, U8.51 (PA14_SWCLK)
/SWDIO: J6.1, U8.50 (PA13_SWDIO)
/V_BAT: F1.2, J1.2, J1.5
GND: C1.1, C2.1, C3.1, C4.1, C5.2, C6.2, C7.1, D2.1 (K), H1.1, H2.1, J2.6, Q1.2 (E), R8.2, R10.2, R17.1, R18.1, R19.2, R20.2, U1.1 (-), U2.2 (GND), U3.2 (GND), U3.4 (GND), U3.5 (GND), U3.11 (RES), U3.12 (SDO/ADDR), U4.1 (GND), U4.10 (GND), U4.12 (GND), U5.1 (S1), U5.3 (S2), U6.1 (S1), U6.3 (S2), U7.4 (GND), U8.2 (GND), U8.3 (GND), U8.14 (GND), U8.15 (GND), U8.31 (GND), U8.32 (GND), U8.34 (GND), U8.35 (GND), U8.37 (GND), U8.39 (GND), U8.41 (GND), U8.61 (GND), U8.62 (GND), U9.3 (GND), U10.7 (GND)
unnamed: AE1.1, U10.3 (RF_IN)
unnamed: AE2.1, U8.33 (RF_ANT)
unnamed: BZ1.2 (+), Q1.3 (C)
unnamed: C2.2, D3.1 (K), U2.1 (VIN), U2.3 (~SHDN)
unnamed: D1.1 (K), R7.1
unnamed: D1.2 (A), D3.2 (A), F1.1, U1.2 (+)
unnamed: D2.2 (A), R1.1
unnamed: Q1.1 (B), R5.1
unnamed: U9.4 (CSB), U9.5 (CSB)
unnamed: U4.13 (LNA_EN), U10.2 (VEN)
unnamed: U4.11 (RF_IN), U10.6 (RF_OUT)

Notes on the sheet:
12.6 * 3k / (10k + 3k) = 2.9
no current means no forward voltage, right?
VERSION 4

Board: 4 copper layers, 13.0 x 53.6 mm, 46 parts (24 on the bottom side), 43 nets.

## KiCad design electronics/mini_controller2/mini_controller.kicad_pcb

Schematic: mini_controller.sch

Parts:
AE1: U.FL; U.FL_Hirose_U.FL-R-SMT-1_Vertical
AE2: ANT-868-PW-LP
BZ1: CMT-0502-75-SMT-TR; XDCR_CMT-0502-75-SMT-TR
C1, C4, C6, C7: 0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C2: 1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C3: 2.2u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C5: 4.7u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D1, D3: ZLLS350TA; D_SOD-523
D2: SMLVN6RGB; LED_ROHM_SMLVN6
F1: C1H25; Fuse_1206_3216Metric_Pad1.42x1.75mm_HandSolder
J1: terminal 1; TerminalBlock_Phoenix_MPT-0,5-4-2.54_1x04_P2.54mm_Horizontal
J2: terminal 2; TerminalBlock_Phoenix_MPT-0,5-4-2.54_1x04_P2.54mm_Horizontal
J3: GND; just_a_pad
J4: Conn_01x04; JST_GH_BM04B-GHS-TBT_1x04-1MP_P1.25mm_Vertical
J5: 3V3; just_a_pad
J6: SWDIO; just_a_pad
J7: SWCLK; just_a_pad
Q1: MMBT3904; SOT-23
R1, R6, R7, R10, R17, R18, R19, R20: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R2, R4: 120; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R3, R5, R13, R14, R15, R16: 500; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R8: 3k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R11, R12: 4.7k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW1: chs-01a; SW_DIP_SPSTx01_Slide_Copal_CHS-01A_W5.08mm_P1.27mm_JPin
U1: JST-RCY; xt30_pigtail
U2: BD33GA5WEFJ; HTSOP-8-1EP_3.9x4.9mm_P1.27mm_EP2.4x3.2mm
U3: NCV51460; SOT-23
U4: MAX-M8C; ublox_MAX
U5, U6: Si7232DN; Vishay_PowerPAK_1212-8_Dual
U7: W25Q16JVS; SOIC-8_5.275x5.275mm_P1.27mm
U8: s76s
U9: MS5607-02BA; LGA-8_3x5mm_P1.25mm
U10: SKY65723-81; Skyworks_SKY65404-31
U12: ADXL375; LGA-14_3x5mm_P0.8mm_LayoutBorder1x6y
j1: power; PinHeader_1x02_P2.54mm_Vertical_SMD

Connections:
/3V3: BZ1.1 (-), C3.2, C5.1, C6.1, C7.2, J4.4, J5.1, R11.1, R12.2, SW1.1, U2.1, U2.2, U4.7, U4.8, U7.3, U8.43, U8.44, U9.1, U9.2, U10.1, U10.2, U12.1, U12.6, U12.7
/3V3_BAK: U3.2, U4.6
/3v3: C4.1, U7.7, U7.8
/BAT_SENSE: R7.2, R8.1, U8.6
/BUZZER: R5.2, R6.2, U8.36
/EXT_RX: J4.2, U8.17
/EXT_TX: J4.3, U8.16
/FLASH_CS: U7.1, U8.18
/FLASH_MISO: U7.2, U8.20
/FLASH_MOSI: U7.5, U8.21
/FLASH_SCK: U7.6, U8.19
/GPS_RX: U4.2, U8.53
/GPS_TX: U4.3, U8.52
/LED_B: R2.2, U8.28
/LED_G: R4.2, U8.26
/LED_R: R3.1, U8.27
/PYRO_1: J2.3, U5.5
/PYRO_1_EN: R13.1, R19.1, U8.25
/PYRO_2: J1.2, U5.6
/PYRO_2_EN: R14.1, R17.2, U8.24
/PYRO_3: J2.1, U6.5
/PYRO_3_EN: R15.1, R20.1, U8.7
/PYRO_4: J1.4, U6.6
/PYRO_4_EN: R16.2, R18.2, U8.13
/SCL3: R11.2, U8.4, U9.8, U12.14
/SDA3: R12.1, U8.5, U9.7, U12.13
/SWCLK: J7.1, U8.51
/SWDIO: J6.1, U8.50
/V_BAT: F1.2, J1.1, J1.3, J2.2, J2.4
GND: AE1.2, C1.1, C2.1, C3.1, C4.2, C5.2, C6.2, C7.1, D2.4, D2.5, D2.6, J3.1, J4.1, Q1.2, R6.1, R8.2, R10.2, R17.1, R18.1, R19.2, R20.2, U1.1 (-), U2.3, U2.4, U2.6, U2.7, U2.9, U3.3, U4.1, U4.10, U4.12, U5.1, U5.3, U6.1, U6.3, U7.4, U8.2, U8.3, U8.14, U8.15, U8.31, U8.32, U8.34, U8.35, U8.37, U8.39, U8.41, U8.61, U8.62, U9.3, U10.7, U12.2, U12.4, U12.5, U12.12, j1.1
unnamed: AE1.1, U10.3
unnamed: AE2.1, U8.33
unnamed: BZ1.2 (+), Q1.3
unnamed: C1.2, D1.2, D3.2, F1.1, U1.2 (+), U3.1
unnamed: C2.2, D3.1, R1.1, U2.8
unnamed: D1.1, R7.1
unnamed: D2.1, R2.1
unnamed: D2.2, R3.2
unnamed: D2.3, R4.1
unnamed: Q1.1, R5.1
unnamed: R1.2, U2.5, j1.2
unnamed: R10.1, SW1.2, U8.59
unnamed: R13.2, U5.4
unnamed: R14.2, U5.2
unnamed: R15.2, U6.4
unnamed: R16.1, U6.2
unnamed: U9.4, U9.5
unnamed: U4.11, U10.6

Notes on the sheet:
main supply
VF: R: 1.8 G: 3.0 B: 2.9
current 3ma
12.6 * 3k / (10k + 3k) = 2.9
no current means no forward voltage, right?
shared cap with ms56
no cap according to datasheet built in reverse voltage
datasheet wants a resistor but it works without, no space for it

Board: 4 copper layers, 14.0 x 54.4 mm, 54 parts (23 on the bottom side), 48 nets.

## KiCad design electronics/v2/fc_v2.kicad_pcb

Parts:
BZ1: Buzzer; CX-0905C
C1: 100nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C2: 100pF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C3: 20uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C4: 10uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C5, C6, C7, C8, C10, C12: 100n; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C9: C; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1, D3, D4, D9, D11: D_Schottky; D_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D2: WS2812B; ws2812-through-hole-5mm
D5: ARMED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D6, D8, D10, D12: D_TVS; D_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D7: SAFE; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
H1, H2, H4, H5: MountingHole; MountingHole_2.2mm_M2_ISO7380
H3: Logo; avatar
H6: Aesir; aesir
J1: Conn_02x03_Odd_Even; PinHeader_2x03_P2.54mm_Vertical
J2: JST_XH_4; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
Q1: MMBT3904; SOT-23
R1: 6k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R2: 2k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R3, R4, R7, R16: 4.7k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R5, R6, R8, R10: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R9: 1k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R11, R12: 400; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R13: 120; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
SW1: SW_DPST_x2; PinHeader_1x02_P2.54mm_Vertical
U1: teensy4
U2: RFM69HCW; Adafruit-RFM69
U3: GY91
U4: SN65HVD230; SOIC-8_3.9x4.9mm_P1.27mm
U5: xt-30; AMASS_XT30U-M_1x02_P5.0mm_Vertical
U6: VXO7805-500-M
U7, U8, U9, U10: terminal-2; terminal-small
U11, U12, U13, U14: BTN7030-1EPA; Infineon_PG-TSDSO-14-22-bottom
U15: NL17SZ17; SC-74-a
U16: w25nxx; SOIC-16W_7.5x10.3mm_P1.27mm

Connections:
3V3: C1.2, C2.1, D7.2 (A), R3.2, R4.2, R5.1, U1.31 (3.3V), U2.1 (VIN), U3.1 (VIN), U4.3 (VCC), U15.5 (VCC), U16.1 (RESET), U16.2 (VCC), U16.3 (RESET), U16.9 (WP)
5V: BZ1.1 (-), D1.1 (K), D3.2 (A), D4.1 (K), D9.1 (K), D11.2 (A), U1.33 (Vin)
12V: C3.1, C10.2, C12.2, R1.1, U5.2 (+), U6.1 (VIN), U11.15 (VS), U12.15 (VS), U13.15 (VS), U14.15 (VS)
/BAT_READ: R1.2, R2.1, U1.24 (17_A3_TX4_SDA1_NO_PWM)
/BUZZ: R6.1, R9.2, U1.30 (23_A9_CRX1)
/CAN_RX: U1.2 (0_RX1_CRX2), U4.4 (R)
/CAN_TX: U1.3 (1_TX1_CTX2), U4.1 (D)
/EXT_RX: J1.6, U1.21 (14_A0_TX3)
/EXT_TX: J1.5, U1.22 (15_A1_RX3)
/FLASH_CS: R5.2, U1.12 (10_CS), U16.7 (CS)
/MISO: U1.14 (12_MISO), U2.6 (MISO), U16.8 (DO)
/MOSI: U1.13 (11_MOSI_CTX1), U2.7 (MOSI), U16.15 (DI)
/P_EN: R7.2, U11.2 (EN), U12.2 (EN), U13.2 (EN), U14.2 (EN)
/P_IN_1: U1.11 (9), U11.6 (IN)
/P_IN_2: U1.10 (8_TX2), U12.6 (IN)
/P_IN_3: U1.9 (7_RX2), U13.6 (IN)
/P_IN_4: U1.8 (6), U14.6 (IN)
/RF_CS: U1.7 (5), U2.8 (CS)
/RF_G0: U1.5 (3), U2.4 (G0)
/RF_RST: U1.6 (4), U2.9 (RST)
/SCK: U1.20 (13_SCK_CRX1_LED), U2.5 (SCK), U16.16 (CLK)
/SCL: J1.3, R4.1, U1.26 (19_A5_SCL0), U3.4 (SCL)
/SDA: J1.4, R3.1, U1.25 (18_A4_SDA0), U3.5 (SDA)
/UNSAFE_P_EN: R10.1, SW1.1 (A), U1.23 (16_A2_RX4_SCL1_NO_PWM), U15.2 (IN)
GND: C1.1, C2.2, C3.2, C4.2, C5.1, C6.1, C7.1, C8.1, C9.2, C10.1, C12.1, D2.1 (VDD), D6.2 (A2), D8.2 (A2), D10.2 (A2), D12.2 (A2), J1.1, J2.4, Q1.2 (E), R2.2, R6.2, R8.1, R10.2, R11.1, R16.2, U1.1 (GND), U1.17 (GND), U1.32 (GND), U2.2 (GND), U3.3 (GND), U4.2 (GND), U4.8 (Rs), U5.1 (-), U6.2 (GND), U7.1 (-), U8.1 (-), U9.1 (-), U10.1 (-), U11.12 (GND), U11.13 (GND), U11.14 (GND), U12.12 (GND), U12.13 (GND), U12.14 (GND), U13.12 (GND), U13.13 (GND), U13.14 (GND), U14.12 (GND), U14.13 (GND), U14.14 (GND), U15.3 (GND), U16.10 (GND)
unnamed: BZ1.2 (+), Q1.3 (C)
unnamed: C4.1, D1.2 (A), U6.3 (VO)
unnamed: C5.2, D6.1 (A1), U7.2 (+), U11.8 (OUT), U11.9 (OUT), U11.10 (OUT)
unnamed: C6.2, D8.1 (A1), U8.2 (+), U12.8 (OUT), U12.9 (OUT), U12.10 (OUT)
unnamed: C7.2, D10.1 (A1), U9.2 (+), U13.8 (OUT), U13.9 (OUT), U13.10 (OUT)
unnamed: C8.2, D12.1 (A1), U10.2 (+), U14.8 (OUT), U14.9 (OUT), U14.10 (OUT)
unnamed: C9.1, D2.3 (VSS), D3.1 (K)
unnamed: D4.2 (A), U1.34 (VUSB)
unnamed: D5.1 (K), R11.2
unnamed: D5.2 (A), R12.2, U15.4 (OUT)
unnamed: D7.1 (K), R12.1
unnamed: D9.2 (A), J2.1
unnamed: D11.1 (K), J1.2
unnamed: J2.2, R13.1, U4.7 (CANH)
unnamed: J2.3, R13.2, U4.6 (CANL)
unnamed: Q1.1 (B), R9.1
unnamed: R8.2, U11.3 (DEN), U12.3 (DEN), U13.3 (DEN), U14.3 (DEN)
unnamed: R7.1, R16.1, SW1.2 (B)
RGB: D2.4 (DIN), U1.4 (2)

Notes on the sheet:
Rocket1 flight controller
1.1
Flash memory - 128MBit
Radio
Power
RGB LED
Expansion port
Buzzer
ARMING
Pyro channels
decoupling capacitor shared
Mechanical
10-DOF
CAN

Board: 2 copper layers, 36.1 x 96.8 mm, 64 parts (45 on the bottom side), 44 nets.

## KiCad design electronics/v1/project.kicad_pcb

Parts:
BAT1: terminal-2; terminal-small
BZ1: Buzzer; buzzer
C1: 100nF; R_Axial_DIN0207_L6.3mm_D2.5mm_P5.08mm_Vertical
C2: 22pF; R_Axial_DIN0207_L6.3mm_D2.5mm_P5.08mm_Vertical
D1: LED_RGBC; LED_D5.0mm-4_RGB
J1: Conn_01x10; 01x10_header
R1, R2: 4.7k; R_Axial_DIN0207_L6.3mm_D2.5mm_P5.08mm_Vertical
R3, R4: 330; R_Axial_DIN0207_L6.3mm_D2.5mm_P5.08mm_Vertical
R5: 1000; R_Axial_DIN0207_L6.3mm_D2.5mm_P5.08mm_Vertical
U1: teensy4
U2: RFM69HCW; Adafruit-RFM69
U3: GY91
U4: W25Q128JV; SOIC-8_5.275x5.275mm_P1.27mm

Connections:
3V3: C2.2, J1.2, U1.31 (3.3V), U2.1 (VIN), U3.1 (VIN), U4.8 (VCC)
/BUZZ: BZ1.1 (-), U1.30 (23_A9_CRX1)
/EXT-CS: J1.5, U1.9 (7_RX2)
/FLASH-CS: U1.12 (10_CS), U4.1 (CS)
/FLASH-HOLD: U1.10 (8_TX2), U4.7 (HOLD)
/FLASH-WP: U1.11 (9), U4.3 (WP)
/LED-B: R4.1, U1.6 (4)
/LED-G: R5.1, U1.5 (3)
/LED-R: R3.1, U1.4 (2)
/MISO: J1.7, U1.14 (12_MISO), U2.6 (MISO), U4.2 (DO)
/MOSI: J1.6, U1.13 (11_MOSI_CTX1), U2.7 (MOSI), U4.5 (DI)
/RF-CS: U1.27 (20_A6_TX5_NO_PWM), U2.8 (CS)
/RF-G0: U1.28 (21_A7_RX5_NO_PWM), U2.4 (G0)
/RF-RST: U1.29 (22_A8_CTX1), U2.9 (RST)
/RX1: J1.10, U1.2 (0_RX1_CRX2)
/SCK: J1.8, U1.20 (13_SCK_CRX1_LED), U2.5 (SCK), U4.6 (CLK)
/SCL: J1.3, U1.26 (19_A5_SCL0), U3.4 (SCL)
/SDA: J1.4, U1.25 (18_A4_SDA0), U3.5 (SDA)
/TX1: J1.9, U1.3 (1_TX1_CTX2)
/bat_read: R1.1, R2.2, U1.22 (15_A1_RX3)
GND: BAT1.1 (-), BZ1.2 (+), C1.1, C2.1, D1.4 (K), J1.1, R2.1, U1.1 (GND), U1.17 (GND), U1.32 (GND), U2.2 (GND), U3.3 (GND), U4.4 (GND)
unnamed: D1.1 (RA), R3.2
unnamed: D1.2 (GA), R5.2
unnamed: D1.3 (BA), R4.2
VIN: BAT1.2 (+), C1.2, R1.2, U1.33 (Vin)

Notes on the sheet:
Rocket1 flight controller

Board: 2 copper layers, 35.6 x 67.9 mm, 15 parts (0 on the bottom side), 25 nets.

## Code that names these connections

File software/flight_controller/include/definitions.h:

#if __has_include("callsign.h")
#   include "callsign.h"
#   define TX_POWER 13
#   define IS_HAM true
#else
#   define TX_POWER 13
#   define IS_HAM false
#endif

#define RADIO_BUF_LEN 128

#define FREQUENCY 433.800
#define MODULATION RH_RF69::ModemConfigChoice::GFSK_Rb4_8Fd9_6

#define PIN_EXT_RX 0
#define PIN_EXT_TX 0
#define PIN_LED_R 2
#define PIN_LED_G 3
#define PIN_LED_B 4
#define PIN_EXT_CS 7
#define PIN_FLASH_HOLD 8
#define PIN_FLASH_WP 9
#define PIN_FLASH_CS 10
#define PIN_MOSI 11
#define PIN_MISO 12
#define PIN_SCK 13
#define PIN_BAT_READ 15
#define PIN_SDA 18
#define PIN_SCL 19
#define PIN_RF_CS 20
#define PIN_RF_G0 21
#define PIN_RF_RST 22
#define PIN_BUZZER 23

#define BAUD 115200

File software/flight_controller/src/relay/relay.cpp:

#include <Arduino.h>
#include "WS2812Serial.h"

#include "RH_RF69.h"
#include "DataProtocol.h"
#include "definitions.h"
#include "rocket.h"

void sendCallback(uint8_t id, uint8_t* buf, uint8_t len);

DataProtocol usb_protocol {sendCallback};
RH_RF69 radio {PIN_RF_CS, PIN_RF_G0};
byte drawingMemory[3];         //  3 bytes per LED
DMAMEM byte displayMemory[12]; // 12 bytes per LED
WS2812Serial rgb(1, displayMemory, drawingMemory, PIN_RGB_TX, WS2812_RGB);

bool error = false;

void initPins() {
    pinMode(PIN_RF_CS, OUTPUT);
    pinMode(PIN_BAT_READ, INPUT);
    pinMode(PIN_RF_RST, OUTPUT);
    pinMode(PIN_FLASH_CS, OUTPUT);
    pinMode(PIN_BUZZER, OUTPUT);
    pinMode(PIN_PYRO_ARM, OUTPUT);
    pinMode(PIN_PYRO_1, OUTPUT);
    pinMode(PIN_PYRO_2, OUTPUT);
    pinMode(PIN_PYRO_3, OUTPUT);
    pinMode(PIN_PYRO_4, OUTPUT);
    
    SPI.setMISO(PIN_MISO);
    SPI.setMOSI(PIN_MOSI);
    SPI.setSCK(PIN_SCK);
    SPI.begin();

    digitalWrite(PIN_RF_CS, HIGH);
    digitalWrite(PIN_FLASH_CS, HIGH);
    digitalWrite(PIN_PYRO_ARM, LOW);
    delay(100);
}

void initRadio() {
    digitalWrite(PIN_RF_RST, LOW);
    delay(100);
    digitalWrite(PIN_RF_RST, HIGH);
    delay(100);
    digitalWrite(PIN_RF_RST, LOW);
    delay(100);
    if (!radio.init()) {
        Serial.println("could not initialize radio modem");
        error = true;
        return;
    }
    radio.setFrequency(FREQUENCY);
    radio.setTxPower(TX_POWER, true);
    radio.setModemConfig(MODULATION);
    if (IS_HAM) { 
        radio.send(CALLSIGN, sizeof(CALLSIGN));
    }
}

void sendCallback(uint8_t id, uint8_t* buf, uint8_t len) {
    rocket::parse_message(id, buf);
    uint8_t out_buf_len = HEADER_SIZE + len;
    uint8_t out_buf[out_buf_len];
    uint8_t index = 0;
    DataProtocol::build_header(id, out_buf, &index);
    memcpy(out_buf + index, buf, len);
    radio.send(out_buf, out_buf_len);
}

void rocket::rx(rocket::handshake_from_everyone_to_everyone msg) {
    rocket::handshake_from_everyone_to_everyone response;
    uint8_t out_buf[response.get_size() + HEADER_SIZE];
    uint8_t index = 0;
    DataProtocol::build_buf(&response, out_buf, &index);
    delay(200);
    Serial.write(out_buf, index);
    delay(500);
}

void setup() {
    Serial.begin(BAUD);
    initPins();
    //rgb.begin();
    initRadio();
    if (!error) {
        //rgb.setPixel(0, WHITE);
        //rgb.show();
    } else {
        //rgb.setPixel(0, ORANGE);
        //rgb.show();
    }
}

void loop() {
    uint8_t radio_buf[255];
    uint8_t radio_len = 255;
    while (Serial.available() > 0) {
        usb_protocol.parse_byte(Serial.read());
    }
    if (radio.recv(radio_buf, &radio_len)) {
        Serial.write(radio_buf, radio_len);
    }
}

## Commit log

2021-01-03 add schematic
2021-01-03 remove .vscode
2021-01-03 add gitignore
2021-01-04 W.I.P software
2021-01-04 misc
2021-01-04 first draft of controller and gateway
2021-01-08 rewrite gateway-link, add dashboard, update controller
2021-01-09 finish dashboard layout
2021-01-14 get everything working
2021-01-14 update protocol and schematics
2021-01-17 Add flash backup
2021-02-04 add comments
2021-05-12 new flight controller tested
2021-05-24 massive commit with everything
2021-05-25 expand protocol
2021-05-29 W.I.P pcb v2
2021-05-30 PCB mostly finished
2021-06-05 fixes on PCB
2021-06-06 fix P-EN
2021-06-18 main fc traces done
2021-08-14 pre routing mini controller
2021-08-16 pre U.FL version
2021-08-17 mini controller finished
2021-08-26 layout for revision 4
2021-08-28 routing finished v4
2021-11-28 restructure and README
